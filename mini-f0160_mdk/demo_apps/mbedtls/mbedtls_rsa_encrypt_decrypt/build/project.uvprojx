# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F0163D7PV MindMotion
  pack: MindMotion.MM32F0160_DFP.0.0.3
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project
  AfterMake: fromelf --bin --output .\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MBEDTLS_CONFIG_FILE=<config-mini-tls1_1.h> BRD_MINI_F0160
  c include: ..;../../../../components/mbedtls/include;../../../../device/drivers;../../../../device/CMSIS/Include;../../../../device
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ../../../../device/mdk/linker/mm32f0163d_flash.scf
  group application
    ../: board_init.c board_init.h clock_init.c clock_init.h config-mini-tls1_1.h main.c pin_init.c pin_init.h
  group drivers
    ../../../../device/drivers/: hal_adc.c hal_adc.h hal_bkp.c hal_bkp.h hal_common.h hal_comp.c hal_comp.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_flexcan.c hal_flexcan.h hal_gpio.c hal_gpio.h hal_hwdiv.c hal_hwdiv.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_i3c.c hal_i3c.h hal_iwdg.c hal_iwdg.h hal_lptim.c hal_lptim.h hal_lpuart.c hal_lpuart.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group device
    ../../../../device/: hal_device_registers.h mm32f0163d.h mm32f0163d_features.h system_mm32f0163d.c system_mm32f0163d.h
    ../../../../device/mdk/: startup_mm32f0163d.s
  group mbedtls
    ../../../../components/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
